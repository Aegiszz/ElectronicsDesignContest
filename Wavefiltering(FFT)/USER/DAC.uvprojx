# Keil uVision project DAC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DAC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\KEY;..\DSP;..\DSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c STM32_WaveOutput.c STM32_WaveOutput.h stm32f10x_tim.h stm32f10x_tim.c stm32f10x_dma.c stm32f10x_dma.h
    ../HARDWARE/ADC/: timer.c timer.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DAC/: dac.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dac.c
  group README
    ../: README.TXT
  group DSP
    ../DSP/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s
software components: CMSIS:CORE 5.3.0
